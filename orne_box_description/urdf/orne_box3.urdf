Commit message: xacroではなくurdfに統一

File: orne_box_description/urdf/orne_box3.urdf (robot description, URDF)
Before this commit: robot orne_box, 7 links, 6 joints
Joints:
- joint rfans16_joint: origin xyz=-0.105 0 0.80 rpy=0 0 0 -> xyz=-0.105 0 0.60 rpy=0 0 0
